# Keil uVision project demo.uvproj, settings and files
target Core (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Src
    ./: STARTUP.A51 main.c box_bsp.c box_bsp.h
